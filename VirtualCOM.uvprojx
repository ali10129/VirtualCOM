# Keil uVision project VirtualCOM.uvprojx, settings and files
target LPC1768 Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(100000000) ELITTLE
  output: VirtualCOM
  c flags: Optim=4 OneElfS=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: VirtualCOM.c USBD_User_CDC_ACM_UART_0.c
  group Documenation
    ./: Abstract.txt
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:Graphic LCD 1.0.0, Board Support:LED 1.0.0, USB:CORE 6.6.10, USB:Device 6.6.10, USB:Device:CDC 6.6.10, CMSIS Driver:SPI:SSP 2.6, CMSIS Driver:USART 2.5, CMSIS Driver:USB Device 2.11, Device:GPDMA 1.2, Device:GPIO 1.1, Device:PIN 1.0, Device:Startup 1.0.0
